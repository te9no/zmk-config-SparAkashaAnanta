/delete-node/ &kscan2;

/ {
    kscan2: kscan2 {
        compatible = "zmk,kscan-gpio-direct";
        input-gpios
            = <&gpio1 12 (GPIO_ACTIVE_LOW | GPIO_PULL_UP)>
            ;
    };
};